# Keil uVision project photon_smart_ring.uvprojx, settings and files
target GR5515_SK (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.5.9.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ESEL ELITTLE
  output: gunter_moon +hex
  AfterMake: fromelf.exe --text -c --output Listings\@L.s   Objects\@L.axf
  AfterMake: fromelf.exe --bin --output Listings\@L.bin Objects\@L.axf
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: GR5515_SK
  c include: ..\Src\platform;..\Src\user;..\Src\config;..\..\..\..\..\components\app_drivers\inc;..\..\..\..\..\components\boards;..\..\..\..\..\components\drivers_ext\gr551x;..\..\..\..\..\components\drivers_ext\st7735;..\..\..\..\..\components\drivers_ext\vs1005;..\..\..\..\..\components\libraries\app_alarm;..\..\..\..\..\components\libraries\app_assert;..\..\..\..\..\components\libraries\app_error;..\..\..\..\..\components\libraries\app_key;..\..\..\..\..\components\libraries\app_log;..\..\..\..\..\components\libraries\app_queue;..\..\..\..\..\components\libraries\app_timer;..\..\..\..\..\components\libraries\at_cmd;..\..\..\..\..\components\libraries\bsp;..\..\..\..\..\components\libraries\dfu_master;..\..\..\..\..\components\libraries\dfu_port;..\..\..\..\..\components\libraries\gui;..\..\..\..\..\components\libraries\gui\gui_config;..\..\..\..\..\components\libraries\hal_flash;..\..\..\..\..\components\libraries\hci_uart;..\..\..\..\..\components\libraries\pmu_calibration;..\..\..\..\..\components\libraries\ring_buffer;..\..\..\..\..\components\libraries\sensorsim;..\..\..\..\..\components\libraries\fault_trace;..\..\..\..\..\components\libraries\utility;..\..\..\..\..\components\patch\ind;..\..\..\..\..\components\profiles\ams_c;..\..\..\..\..\components\profiles\ancs_c;..\..\..\..\..\components\profiles\ans;..\..\..\..\..\components\profiles\ans_c;..\..\..\..\..\components\profiles\bas;..\..\..\..\..\components\profiles\bas_c;..\..\..\..\..\components\profiles\bcs;..\..\..\..\..\components\profiles\bps;..\..\..\..\..\components\profiles\common;..\..\..\..\..\components\profiles\cscs;..\..\..\..\..\components\profiles\cts;..\..\..\..\..\components\profiles\cts_c;..\..\..\..\..\components\profiles\dis;..\..\..\..\..\components\profiles\dis_c;..\..\..\..\..\components\profiles\gls;..\..\..\..\..\components\profiles\gus;..\..\..\..\..\components\profiles\gus_c;..\..\..\..\..\components\profiles\hids;..\..\..\..\..\components\profiles\hrrcps;..\..\..\..\..\components\profiles\hrs;..\..\..\..\..\components\profiles\hrs_c;..\..\..\..\..\components\profiles\hts;..\..\..\..\..\components\profiles\ias;..\..\..\..\..\components\profiles\lls;..\..\..\..\..\components\profiles\ls;..\..\..\..\..\components\profiles\ndcs;..\..\..\..\..\components\profiles\otas;..\..\..\..\..\components\profiles\otas_c;..\..\..\..\..\components\profiles\pass;..\..\..\..\..\components\profiles\pass_c;..\..\..\..\..\components\profiles\pcs;..\..\..\..\..\components\profiles\rscs;..\..\..\..\..\components\profiles\rscs_c;..\..\..\..\..\components\profiles\rtus;..\..\..\..\..\components\profiles\ths;..\..\..\..\..\components\profiles\ths_c;..\..\..\..\..\components\profiles\thscps;..\..\..\..\..\components\profiles\tps;..\..\..\..\..\components\profiles\wechat;..\..\..\..\..\components\sdk\;..\..\..\..\..\drivers\inc;..\..\..\..\..\external\freertos\include;..\..\..\..\..\external\segger_rtt;..\..\..\..\..\toolchain\cmsis\include;..\..\..\..\..\toolchain\gr551x\include;..\..\..\..\..\toolchain\gr551x\source\arm;..\..\..\..\..\components\photon_drivers;..\Src\gh3x2x\1-drv_lib;..\Src\gh3x2x\2-algo_lib\algo_params;..\Src\gh3x2x\3-demo_code\demo_algo_code\goodix_algo_application\inc;..\Src\gh3x2x\3-demo_code\demo_algo_code\goodix_algo_call\inc;..\Src\gh3x2x\3-demo_code\demo_kernel_code\inc;..\Src\gh3x2x\3-demo_code\demo_mp_code\inc;..\Src\gh3x2x\ble_service;..\..\..\..\..\photon_drivers;..\Src\gunter_ble_services
  library: MicroLIB
  memory RVCT4: ROM 0x38000 size 0x28000
  memory RVCT9: RAM 0x3000a000 size 0x36000
  scatter file: ..\..\..\..\..\toolchain\gr551x\source\arm\flash_scatter_common.sct
  link misc: ..\..\..\..\..\components\patch\symbol_table\rom_symbol.txt
  group gr_startup
    ../../../../../toolchain/gr551x/source/arm/: startup_gr55xx.s
  group gr_arch
    ../../../../../toolchain/gr551x/source/: interrupt_gr55xx.c system_gr55xx.c platform_gr55xx.c
  group gr_stack_lib
    ../../../../../components/sdk/linker/lib/: ble_sdk.lib
  group gr_drivers
    ../../../../../drivers/src/: gr55xx_hal.c gr55xx_hal_exflash.c gr55xx_hal_xqspi.c gr55xx_hal_pwr.c gr55xx_hal_gpio.c gr55xx_hal_aon_gpio.c gr55xx_hal_uart.c gr55xx_hal_calendar.c gr55xx_hal_spi.c gr55xx_hal_adc.c gr55xx_hal_i2c.c
  group gr_app_drivers
    ../../../../../components/app_drivers/src/: app_dma.c app_gpiote.c app_io.c app_pwr_mgmt.c app_uart.c app_systick.c app_rtc.c app_spi.c app_adc.c app_i2c.c
  group gr_drivers_ext
    ../../../../../components/drivers_ext/gr551x/: gr551x_adc_voltage_api.c
  group gr_libraries
    ../../../../../components/libraries/utility/: utility.c
    ../../../../../components/libraries/ring_buffer/: ring_buffer.c
    ../../../../../components/libraries/app_key/: app_key.c app_key_core.c
    ../../../../../components/libraries/app_timer/: app_timer.c
    ../../../../../components/libraries/pmu_calibration/: pmu_calibration.c
    ../../../../../components/libraries/bsp/: bsp.c
    ../../../../../components/libraries/app_log/: app_log.c app_log_store.c app_log_dump_port.c
    ../../../../../components/libraries/app_error/: app_error.c cortex_backtrace.c
    ../../../../../components/libraries/app_assert/: app_assert.c
    ../../../../../components/libraries/fault_trace/: fault_trace.c
    ../../../../../components/libraries/dfu_port/: dfu_port.c
  group gr_profiles
    ../../../../../components/profiles/common/: ble_prf_utils.c
    ../../../../../components/profiles/hrs/: hrs.c
    ../../../../../components/profiles/otas/: otas.c
    ../../../../../components/profiles/dis/: dis.c
    ../../../../../components/profiles/ls/: ls.c
  group external
    ../../../../../external/segger_rtt/: SEGGER_RTT.c
  group user_callback
    ../Src/user_callback/: user_gap_callback.c user_gatt_common_callback.c user_gattc_callback.c user_l2cap_callback.c user_sm_callback.c
  group user_platform
    ../Src/platform/: user_periph_setup.c
  group user_app
    ../../../../../components/boards/: GR5515_SK.h
    ./../Src/config/: custom_config.h
    ../Src/user/: main.c user_app.c user_rtc.c user_common.c user_func_ctrl.c user_timer.c user_file_sys.c user_lsm6dso.c user_battery.c user_i2c.c user_nfc.c user_data_center.c user_ble.c user_dfu.c user_hrv.c user_3x2x_log.c
  group photon_drivers
    ../../../../../photon_drivers/GD25LE128E/: Flash_Spi.c
    ../../../../../photon_drivers/NST112/: nst112x.c
    ../../../../../photon_drivers/LSM6DSO/: lsm6dso.c lsm6dso_reg.c
    ../../../../../photon_drivers/STNS01/: stns01.c
    ../../../../../photon_drivers/ST25DV04KC/: st25dv.c st25dv_reg.c
  group gh3x2x_drv_lib
    ../Src/gh3x2x/1-drv_lib/: gh3x2x_drv.h
    ../Src/gh3x2x/1-drv_lib/keil_M4/_build/: libgh3x2x_drv_cortexM4l_band_keil_agc.lib libgh3x2x_drv_cortexM4l_band_keil_ecg.lib libgh3x2x_drv_cortexM4l_band_keil_kernel.lib libgh3x2x_drv_cortexM4l_band_keil_zip.lib
  group gh3x2x_drv_lib_debug
    ../Src/gh3x2x/1-drv_lib/: gh3x2x_drv.h
    ../Src/gh3x2x/1-drv_lib/keil_M4/_build_dbg/: libgh3x2x_drv_cortexM4l_band_keil_agc.lib libgh3x2x_drv_cortexM4l_band_keil_ecg.lib libgh3x2x_drv_cortexM4l_band_keil_kernel.lib libgh3x2x_drv_cortexM4l_band_keil_zip.lib
  group gh3x2x_algo
    ../Src/gh3x2x/3-demo_code/demo_algo_code/goodix_algo_application/inc/: gh3x2x_demo_algo_config.h
    ../Src/gh3x2x/3-demo_code/demo_algo_code/goodix_algo_application/src/: gh3x2x_demo_accppg_sync.c gh3x2x_demo_algo_call.c gh3x2x_demo_algo_config.c gh3x2x_demo_algo_frame.c gh3x2x_demo_algo_hook.c gh3x2x_demo_algo_memory.c gh3x2x_demo_algo_reg_array.c gh3x2x_demo_strategy.c
    ../Src/gh3x2x/3-demo_code/demo_algo_code/goodix_algo_call/src/: gh3x2x_demo_algo_call_adt.c gh3x2x_demo_algo_call_af.c gh3x2x_demo_algo_call_bt.c gh3x2x_demo_algo_call_ecg.c gh3x2x_demo_algo_call_hr.c gh3x2x_demo_algo_call_hrv.c gh3x2x_demo_algo_call_hsm.c gh3x2x_demo_algo_call_nadt.c gh3x2x_demo_algo_call_resp.c gh3x2x_demo_algo_call_spo2.c
  group gh3x2x_algo_lib
    ../Src/gh3x2x/2-algo_lib/algo_lib_M4_keil/: cortexM4_keil_af.lib cortexM4_keil_bt.lib cortexM4_keil_common.lib cortexM4_keil_ecg.lib cortexM4_keil_hr.lib cortexM4_keil_hrv.lib cortexM4_keil_hsm.lib cortexM4_keil_nadt.lib cortexM4_keil_resp.lib cortexM4_keil_spo2.lib
    ../Src/gh3x2x/2-algo_lib/algo_params/: heart_net_org_dll.c heart_net_org_export.h HRNet_knConfNetWeights.c HRNet_knSceneNetWeights.c HRNet_knSceneSwitchWeights.c HRNet_knWeights.c HRNet_knWeightsSmall.c pv_v2.0.1_spo2wrnet_for_cardiffA_v2.23_masimo_0ae2fc.c
  group gh3x2x_kernel
    ../Src/gh3x2x/3-demo_code/demo_kernel_code/inc/: gh3x2x_demo_config.h
    E:/A_SDK/Goodix/GH3220/GH3x2x外发资料/3. 软件设计/GH3X2X_V41xx版本算法驱动以及移植文档/V4100版本驱动库以及移植指南/SDK1.70 GR5515+GH3X2X V4100移植DEMO/ble_app_gh3x2x_v4100_public/Src/gh3x2x_code/3-demo_code/demo_kernel_code/inc/: gh3x2x_demo_io_config.h
    ../Src/gh3x2x/3-demo_code/demo_kernel_code/src/: gh3x2x_demo.c gh3x2x_demo_hook.c gh3x2x_demo_protocol.c gh3x2x_demo_reg_array.c gh3x2x_demo_soft_adt.c gh3x2x_demo_user.c
  group ble_service
    ../Src/gh3x2x/ble_service/: health.c
    ../Src/gunter_ble_services/: gunter_ble_ctrl.c
